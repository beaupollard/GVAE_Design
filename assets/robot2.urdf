Commit message: Pushing changes from a long time ago.

File: assets/robot2.urdf (robot description, URDF)
Before this commit: robot cart, 6 links, 5 joints
Links:
- link pendulum: geometry visual cylinder length=0.4 radius=0.02
